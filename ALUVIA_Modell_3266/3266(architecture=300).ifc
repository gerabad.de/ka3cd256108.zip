Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_581/temp/tmp_3556_130_lZyGg/format_1/3266(architecture=300).ifc
Time: 2025-09-01T09:05:02
Made in: PARTsolutions

# IfcProject, 3266(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3266(architecture=300)
In: BUILDING
Description: 3266(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3266
ePset_PARTsolutions - NB: 3266(architecture=300); NN: 3266; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3266(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3266; B: 3266_aluvia_1500x1000.png; C: ALUVIA; E: KALDEWEI; EF000049: 1500; EF004567: 1000; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 1000; etim7_EC003246_LENGTH: 1500
